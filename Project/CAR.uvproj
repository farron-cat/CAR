# Keil uVision project CAR.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: CAR +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\APP;..\BSP;..\MCU
  group APP
    ../APP/: main.c
  group BSP
    ../BSP/: bsp_delay.c bsp_led.c bsp_light.c bsp_light.h bsp_horn.c bsp_horn.h bsp_motor_io.c bsp_timer.c bsp_key.c bsp_uart.c bsp_bluetooth.c bsp_motor_dirver.c bsp_control.c bsp_control.h bsp_ultrasonic.c bsp_adc.c bsp_tracker.c
  group MCU
    ../MCU/: STARTUP.A51 STC8G_H_GPIO.c STC8G_H_Delay.c STC8H_PWM.c STC8H_PWM_Isr.c STC8G_H_NVIC.c STC8G_H_Timer.c STC8G_H_Exti.c STC8G_H_UART.c STC8G_H_UART_Isr.c STC8G_H_ADC.c STC8G_H_ADC_Isr.c
